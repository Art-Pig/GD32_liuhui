# Keil uVision project 001LH-EXTI-LED.uvprojx, settings and files
target LH-EXTI-LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 001LH-EXTI-LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\App;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F10x\Include;..\Firmware\GD32F10x_standard_peripheral\Include;..\Hardware;..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: main.c DELAY.c EXTI.c DELAY.h EXTI.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Firmware
    ../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c
  group Hardware
    ../Hardware/: KEY.c LED.c KEY.h LED.h
  group User
    ../User/: gd32f10x_it.c systick.c
