# Keil uVision project 001LH_LIB_LED.uvprojx, settings and files
target LED-LIB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LIB-LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F10x\Include;..\Firmware\GD32F10x_standard_peripheral\Include;..\User;..\App;..\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: main.c DELAY.c
  group User
    ../User/: gd32f10x_it.c systick.c
  group Firmware
    ../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Hardware
    ../Hardware/: LED.c LED.h
